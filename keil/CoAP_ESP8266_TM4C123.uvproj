# Keil uVision project CoAP_ESP8266_TM4C123.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: CoAP_ESP8266_TM4C123
  c flags: Optim=1 OneElfS=1
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ..\inc;..\inc\hw;..\driverlib;..\TM4C123;..\OS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: startup.s
    ../src/: main.c
  group driverlib
    ../driverlib/src/: uart.c interrupt.c cpu.c sysctl.c gpio.c
  group hal
    ../src/: hal_uart.c hal_uart_int.c
  group OS
    ../OS/src/: OS.c OS_FIFO.c OS_Logger.c OS_Signal.c OS_Task_Lists.c List.c
